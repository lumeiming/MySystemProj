# Keil uVision project project.uvproj, settings and files
target RT-Thread LPC17xx (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: rtthread-lpc
  c flags: Optim=1
  c include: applications;.;CMSIS\CM3\DeviceSupport\NXP\LPC17xx;..\..\document\RT_thread\rt-thread\components\CMSIS\Include;drivers;..\..\document\RT_thread\rt-thread\include;..\..\document\RT_thread\rt-thread\libcpu\arm\cortex-m3;..\..\document\RT_thread\rt-thread\libcpu\arm\common;..\..\document\RT_thread\rt-thread\components\finsh;..\..\document\RT_thread\rt-thread\components\net\lwip-1.4.1\src;..\..\document\RT_thread\rt-thread\components\net\lwip-1.4.1\src\include;..\..\document\RT_thread\rt-thread\components\net\lwip-1.4.1\src\include\ipv4;..\..\document\RT_thread\rt-thread\components\net\lwip-1.4.1\src\arch\include;..\..\document\RT_thread\rt-thread\components\net\lwip-1.4.1\src\include\netif
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c platform.c startup.c
  group CMSIS
    CMSIS/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
    CMSIS/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group Drivers
    drivers/: board.c emac.c led.c spi.c uart.c
  group Kernel
    ../../document/RT_thread/rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../document/RT_thread/rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../document/RT_thread/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group finsh
    ../../document/RT_thread/rt-thread/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group LwIP
    ../../document/RT_thread/rt-thread/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../document/RT_thread/rt-thread/components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../../document/RT_thread/rt-thread/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../document/RT_thread/rt-thread/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../document/RT_thread/rt-thread/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
